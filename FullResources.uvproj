# Keil uVision project FullResources.uvproj, settings and files
target TESLIN (MCS-51)
  device: SC92F7322 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: Teslin +hex
  c flags: Optimize=8
  c define: XUART_LOG  XMOTOR_PARAM_TEST  TIME2_ENABLE  XDC_INTERRUPT   VIB_TIME_ENABLE  FOUR_BUTTON  xLOWPOWER_DISABLEMOTOR
  group Teslin
    ./: STARTUP.A51
    ./c/: main.c EX_Init.c Device.c DRV_ADC.c DRV_GPIO.c DRV_PWM.c DRV_Timer.c DRV_Uart.c
    ./HAL/: HAL_Button.c HAL_Battery.c HAL_Temperature.c
